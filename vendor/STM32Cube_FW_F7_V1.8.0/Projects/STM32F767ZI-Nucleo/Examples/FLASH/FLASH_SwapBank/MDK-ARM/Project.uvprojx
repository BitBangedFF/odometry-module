# Keil uVision project Project.uvprojx, settings and files
target FLASH_SwapBank_Bank1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.3
  cpu: IROM(0x08000000-0x081FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: FLASH_SwapBank_Bank1
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx,USE_STM32F7XX_NUCLEO_144,FLASH_BANK1
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F7xx_Nucleo_144;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_flash.c stm32f7xx_hal_adc.c stm32f7xx_hal_uart.c stm32f7xx_hal_cortex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_dma.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Example/MDK-ARM
    ./: startup_stm32f767xx.s
  group Drivers/BSP/STM32F767ZI-Nucleo
    ../../../../../../Drivers/BSP/STM32F7xx_Nucleo_144/: stm32f7xx_nucleo_144.c
  group Example/User
    ../Src/: main.c stm32f7xx_it.c
target FLASH_SwapBank_Bank2 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.3
  cpu: as above
  output: FLASH_SwapBank_Bank2
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx,USE_STM32F7XX_NUCLEO_144
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 4.3.0
